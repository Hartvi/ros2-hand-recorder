Commit message: [ik] publish pose target in topic

File: src/hand_publisher/urdf/gen3_7dof/urdf/GEN3_URDF_V12.urdf (robot description, URDF)
Before this commit: robot GEN3_URDF_V12, 9 links, 8 joints
Links:
- link base_link: mass 1.697 -> None
